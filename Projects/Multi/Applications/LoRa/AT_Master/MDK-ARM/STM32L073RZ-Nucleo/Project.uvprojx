# Keil uVision project Project.uvprojx, settings and files
target I_NUCLEO_LRWAN1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L073RZHx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: I_NUCLEO_LRWAN1 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx,USE_STM32L0XX_NUCLEO,USE_I_NUCLEO_LRWAN1
  c misc: --C99
  c include: ../../inc;../../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../../Drivers/BSP/Components/Common;../../../../../../../Drivers/BSP/Components/hts221;../../../../../../../Drivers/BSP/Components/lps25hb;../../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../../Drivers/BSP/MDM32L07X01;../../../../../../../Drivers/BSP/I_NUCLEO_LRWAN1;../../../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../../../Middlewares/Third_Party/Lora/Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Doc
    ../../: readme.txt
  group Application/User
    ../../src/: stm32l0xx_it.c hw_rtc.c bsp.c stm32l0xx_hw.c stm32l0xx_hal_msp.c tiny_sscanf.c hw_usart.c lora_driver.c main.c debug.c hw_gpio.c tiny_vsnprintf.c
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver_HL.c HTS221_Driver.c
    ../../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_uart.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_rtc.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_flash.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_adc.c
  group Drivers/BSP/MDM32L07X01
    ../../../../../../../Drivers/BSP/MDM32L07X01/: atcmd.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/BSP/STM32L0xx_Nucleo
    ../../../../../../../Drivers/BSP/STM32L0xx_Nucleo/: stm32l0xx_nucleo.c
  group Middlewares/lora/Utilities
    ../../../../../../../Middlewares/Third_Party/Lora/Utilities/: delay.c low_power_manager.c utilities.c timeServer.c
  group Drivers/BSP/I_NUCLEO_LRWAN1
    ../../../../../../../Drivers/BSP/I_NUCLEO_LRWAN1/: i_nucleo_lrwan1_temperature.c i_nucleo_lrwan1_pressure.c i_nucleo_lrwan1_wm_sg_sm_xx.c i_nucleo_lrwan1_humidity.c i_nucleo_lrwan1.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_temperature.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_humidity.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_temperature.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_humidity.c
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Drivers/BSP/LRWAN_NS1
    ../../../../../../../Drivers/BSP/LRWAN_NS1/: lrwan_ns1.c lrwan_ns1_atcmd.c lrwan_ns1_humidity.c lrwan_ns1_pressure.c lrwan_ns1_temperature.c
target MDM32L07X01 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MDM32L07X01 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx,USE_STM32L0XX_NUCLEO,USE_MDM32L07X01
  c include: ../../inc;../../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../../Drivers/BSP/Components/Common;../../../../../../../Drivers/BSP/Components/hts221;../../../../../../../Drivers/BSP/Components/lps25hb;../../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1;../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2;../../../../../../../Drivers/BSP/MDM32L07X01;../../../../../../../Drivers/BSP/I_NUCLEO_LRWAN1;../../../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../../../Middlewares/Third_Party/Lora/Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
target LRWAN_NS1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: as above
  output: LRWAN_NS1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx,USE_STM32L0XX_NUCLEO,USE_LRWAN_NS1
  c include: ../../inc;../../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../../Drivers/BSP/Components/Common;../../../../../../../Drivers/BSP/Components/hts221;../../../../../../../Drivers/BSP/Components/lps25hb;../../../../../../../Drivers/BSP/Components/lps22hb;../../../../../../../Drivers/BSP/STM32L0xx_Nucleo;../../../../../../../Middlewares/Third_Party/Lora/Utilities;..\..\..\..\..\..\..\Drivers\BSP\LRWAN_NS1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
