# IAR project Lora.ewp, settings and files
configuration mlm32l07x01 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L072CZ ST STM32L072CZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L072xx; USE_B_L072Z_LRWAN1; USE_HAL_DRIVER; USE_BAND_868; USE_MODEM_LORA
  ICCARM.CCIncludePath2: ../../inc; ../../../../../../../Drivers/BSP/B-L072Z-LRWAN1; ../../../../../../../Drivers/BSP/MLM32L07X01; ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Middlewares/Third_Party/Lora/Crypto; ../../../../../../../Middlewares/Third_Party/Lora/Mac; ../../../../../../../Middlewares/Third_Party/Lora/Phy; ../../../../../../../Middlewares/Third_Party/Lora/Utilities; ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1; ../../../../../../../Drivers/BSP/Components/Common; ../../../../../../../Drivers/BSP/Components/hts221; ../../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../../Drivers/BSP/Components/sx1276; ../../../../../../../Middlewares/Third_Party/Lora/Core
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lora.bin
  ILINK.IlinkOutputFile: mlm32l07x01.out
  ILINK.IlinkIcfFile: stm32l072xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../../: readme.txt
  group Drivers/BSP/B_L072Z_LRWAN1
    ../../../../../../../Drivers/BSP/B-L072Z-LRWAN1/: b-l072z-lrwan1.c
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/sx1276/: sx1276.c
  group Drivers/BSP/MLM32L07X01
    ../../../../../../../Drivers/BSP/MLM32L07X01/: mlm32l07x01.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Middlewares/Lora/Utilities
    ../../../../../../../Middlewares/Third_Party/Lora/Utilities/: delay.c low_power_manager.c timeServer.c utilities.c
  group Projects/EWARM
    ./: startup_stm32l072xx.s
  group Projects/PingPong
    ../../src/: debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c vcom.c
